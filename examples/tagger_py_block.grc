options:
  parameters:
    author: lab
    generate_options: qt_gui
    id: packet_gen
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      __doc__ = """
      This demonstrates the expected input to the frequency hopping driver for a single stream.
      It tags the stream with frequency hop words
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
      	def __init__(self):
      		gr.sync_block.__init__(
      			self,
      			name='Frequency Tagger',
      			in_sig=[np.complex64],
      			out_sig=[np.complex64]
      		)
      		# the number of samples we are going to wait untill tagging
      		self.next_packet_index = 0
      		# the frequency we're tagging the next packet with
      		self.next_packet_freq = 0

      	def _tag_stream(self,len_output_items):
      		key = pmt.intern(f"freq")
      		while self.next_packet_index < len_output_items:
      			value = pmt.intern(f"{'%g'%self.next_packet_freq}")
      			self.add_item_tag(0,self.nitems_written(0) + self.next_packet_index,key,value)
      			# increment the tag frequency
      			self.next_packet_freq += 0.01
      			if self.next_packet_freq > 0.5:
      				self.next_packet_freq = 0
      			# somewhat randomize the tag spread for the next tag
      			self.next_packet_index += np.random.randint(100,200)
      		# prepare for next batch
      		self.next_packet_index -= len_output_items

      	def work(self, input_items, output_items):
      		"""example: multiply with constant"""
      		output_items[0][:] = input_items[0]
      		self._tag_stream(len(output_items[0]))
      		return len(output_items[0])
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
