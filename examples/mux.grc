options:
  parameters:
    author: lab
    generate_options: qt_gui
    id: mux
    output_language: python
    qt_qss_theme: dark.qss
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: select
  id: variable_qtgui_chooser
  parameters:
    label0: '0'
    label1: '1'
    label2: '2'
    num_opts: '3'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0.01'
    offset: '0'
    phase: '0'
    samp_rate: '1'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0.05'
    offset: '0'
    phase: '0'
    samp_rate: '1'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0.1'
    offset: '0'
    phase: '0'
    samp_rate: '1'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 2**15
    type: float
  states: {}
- name: gr_phil_mux_0
  id: gr_phil_mux
  parameters:
    dtype: float
    num_inputs: '3'
    select: select
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '1000'
    fc: '0'
    fftsize: 2**12
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', gr_phil_mux_0, '0']
- [analog_sig_source_x_0_0, '0', gr_phil_mux_0, '1']
- [analog_sig_source_x_0_0_0, '0', gr_phil_mux_0, '2']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [gr_phil_mux_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
