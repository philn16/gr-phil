options:
  parameters:
    generate_options: qt_gui
    id: symbol_sync_uhd
    output_language: python
    run_options: run
  states: {}

blocks:
- name: QPSK_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: awgn_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tab0@0: 1,0'
    orient: Qt.Horizontal
    start: '0'
    step: '1e-3'
    stop: '3'
    value: '0'
  states: {}
- name: constellation
  id: variable
  parameters:
    value: np.array([1,1j,-1,-1j])
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.22'
  states: {}
- name: freq_hetrodyne
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tab0@0: 2,0'
    label: freq_hetrodyne
    orient: Qt.Horizontal
    start: '-0.5'
    step: '1e-3'
    stop: '0.5'
    value: '0.2'
  states: {}
- name: freq_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tab0@0: 3,0'
    label: freq_loop_bw
    orient: Qt.Horizontal
    start: '1e-4'
    step: '1e-4'
    stop: '1'
    value: '0.001'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '64'
  states: {}
- name: rrc_taps_mod
  id: variable
  parameters:
    value: np.array(firdes.root_raised_cosine(1, 1, 1.0/float(sps), eb, 200))
  states: {}
- name: rrc_taps_nfilts
  id: variable
  parameters:
    value: np.array(firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), eb, 200*nfilts))
  states: {}
- name: rx_freq_mhz
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tab0@1: 1,0'
    label: rx_freq_mhz
    orient: Qt.Horizontal
    start: '0'
    step: '1e-1'
    stop: '2000'
    value: '1501'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tab0@1: 1,1'
    label: rx_gain
    orient: Qt.Horizontal
    start: '0'
    step: '.1'
    stop: '60'
    value: '40'
  states: {}
- name: rx_gain_digital
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tab0@0: 0,0'
    label: rx_gain_digital
    orient: Qt.Horizontal
    start: '0.01'
    step: '1e-3'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 480e3
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tab0@0: 3,1'
    label: timing_loop_bw
    orient: Qt.Horizontal
    start: '1e-3'
    step: '1e-3'
    stop: '0.1'
    value: '0.01'
  states: {}
- name: tx_freq_mhz
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tab0@1: 0,0'
    label: tx_freq_mhz
    orient: Qt.Horizontal
    start: '0'
    step: '1e-2'
    stop: '2000'
    value: '1501'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tab0@1: 0,1'
    label: tx_gain
    orient: Qt.Horizontal
    start: '0'
    step: '.1'
    stop: '60'
    value: '30'
  states: {}
- name: tx_gain_digital
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tab0@0: 0,1'
    label: rx_gain_digital
    orient: Qt.Horizontal
    start: '0.01'
    step: '1e-3'
    stop: '4'
    value: '1'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: awgn_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_hetrodyne
    offset: '0'
    phase: '0'
    samp_rate: '1'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-freq_hetrodyne'
    offset: '0'
    phase: '0'
    samp_rate: '1'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rx_gain_digital
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_gain_digital
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_patterned_interleaver_0
  id: blocks_patterned_interleaver
  parameters:
    pattern: '[0]+[1]*(sps-1)'
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: 3e3
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: constellation[get_seq(8,2)]
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 0.01 if freq_loop_bw == 0 else freq_loop_bw
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: 1/2**(1/2)
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps_nfilts
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: gr_phil_mux_0
  id: gr_phil_mux
  parameters:
    dtype: complex
    num_inputs: '2'
    select: 1 if freq_loop_bw==0 else 0
  states: {}
- name: gr_phil_symbol_bert_0
  id: gr_phil_symbol_bert
  parameters:
    constellation: constellation
    nbits_prbs: '8'
    print_samp_interval: int(1e5)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from pyphil.symbol_sync import get_seq
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: rrc_taps_mod*(1/np.max(np.abs(rrc_taps_mod)))*0.5
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    note: A Tx Gain of 30 puts out -15 dbm at full scale, the largest safe value in loopback mode
  states: {}
- name: note_1
  id: note
  parameters:
    note: Using ettus USRP N320
  states: {}
- name: note_2
  id: note
  parameters:
    note: We have a 30 dB attenuator
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'tab1@0: 0,0,20,1'
    label1: Before Carrier Sync
    size: 2**14
    type: complex
    update_time: '0.2'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 2**12
    gui_hint: 'tab1@1: 0,0,20,1'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 2**12
    gui_hint: 'tab1@2: 0,0,20,1'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: sps
  id: parameter
  parameters:
    label: sps
    short_id: s
    type: intx
    value: '8'
  states: {}
- name: tab0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,1
    label0: Digital Config
    label1: RF Config
    num_tabs: '2'
  states: {}
- name: tab1
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,9,1
    label0: Constellation (Symbols)
    label1: Gui Sink Rx
    label2: Gui Sink Tx
    num_tabs: '3'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tx_freq_mhz*1e6
    dev_addr: '"addr=172.16.0.10"'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: rx_freq_mhz*1e6
    dc_offs_enb0: '""'
    dev_addr: '"addr=172.16.0.10"'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_patterned_interleaver_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_patterned_interleaver_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_vector_source_x_0, '0', blocks_patterned_interleaver_0, '0']
- [digital_costas_loop_cc_0_0, '0', gr_phil_mux_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', gr_phil_mux_0, '1']
- [gr_phil_mux_0, '0', gr_phil_symbol_bert_0, '0']
- [gr_phil_mux_0, '0', qtgui_const_sink_x_0_1, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_xx_0, '1']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
