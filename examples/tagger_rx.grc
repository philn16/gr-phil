options:
  parameters:
    generate_options: qt_gui
    id: tagger_rx
    output_language: python
    qt_qss_theme: dark.qss
    title: Not titled yet
  states: {}

blocks:
- name: period
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1
    type: int
    value: '200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0.03'
    offset: '0'
    phase: '0'
    samp_rate: '1'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: gr_phil_msg_tagger_0
  id: gr_phil_msg_tagger
  parameters:
    dtype: float
    period: period
  states: {}
- name: gr_phil_tagger_rx_0
  id: gr_phil_tagger_rx
  parameters:
    dtype: float
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 1,0
    key: freq
    label: tag_key_pair
    type: float
    value: '0.1e-3'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,2
    size: 2**12
    srate: '1'
    type: float
    ymax: '1.1'
    ymin: '-1.1'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', gr_phil_msg_tagger_0, '0']
- [gr_phil_msg_tagger_0, '0', gr_phil_tagger_rx_0, '0']
- [gr_phil_tagger_rx_0, '0', qtgui_time_sink_x_0, '0']
- [qtgui_edit_box_msg_0_0, msg, gr_phil_msg_tagger_0, tag_key]

metadata:
  file_format: 1
