options:
  parameters:
    author: lab
    generate_options: qt_gui
    id: uhd_n320
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: rx_freq_mhz
  id: variable_qtgui_range
  parameters:
    label: rx_freq_mhz
    orient: Qt.Horizontal
    start: '0'
    step: '1e-1'
    stop: '2000'
    value: '1000.1'
  states: {}
- name: rx_gain
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tx_freq_mhz
  id: variable_qtgui_range
  parameters:
    label: tx_freq_mhz
    orient: Qt.Horizontal
    start: '0'
    step: '1e-2'
    stop: '2000'
    value: '1000'
  states: {}
- name: tx_gain
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '20'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: find_cazac_sequence(30,bw=1)*0.9
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from pyphil.cazac import find_cazac_sequence
  states: {}
- name: note_0
  id: note
  parameters:
    note: USRP 10Gbe address is 172.16.0.10. Local address is 172.16.0.100
  states: {}
- name: note_1
  id: note
  parameters:
    note: tx_gain maxes out at 60
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: rx_gain maxes out at 60
  states: {}
- name: note_2
  id: note
  parameters:
    note: there seems to be an Rx RF blocker at DC. This is whyu the Rx frequency starts at an offset
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq_mhz
    fftsize: 2**12
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tx_freq_mhz*1e6
    dev_addr: '"addr=172.16.0.10"'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: rx_freq_mhz*1e6
    dc_offs_enb0: '""'
    dev_addr: '"addr=172.16.0.10"'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_vector_source_x_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
