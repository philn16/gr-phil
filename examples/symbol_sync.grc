options:
  parameters:
    generate_options: qt_gui
    id: symbol_sync
    output_language: python
    run_options: run
  states: {}

blocks:
- name: QPSK_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: awgn_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0
    orient: Qt.Horizontal
    start: '0'
    step: '1e-3'
    stop: '3'
    value: '0'
  states: {}
- name: constellation
  id: variable
  parameters:
    value: np.array([1,1j,-1,-1j])
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.22'
  states: {}
- name: freq_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0
    label: freq_loop_bw
    orient: Qt.Horizontal
    start: '1e-4'
    step: '1e-4'
    stop: '1'
    value: '0.001'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0
    label: freq_offset
    orient: Qt.Horizontal
    start: '-0.5'
    step: '1e-3'
    stop: '0.5'
    value: '0'
  states: {}
- name: multiply
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: multiply
    orient: Qt.Horizontal
    start: '0.01'
    step: '1e-3'
    stop: '4'
    value: '1'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '64'
  states: {}
- name: resamp_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    label: resamp_rate
    orient: Qt.Horizontal
    start: 1-0.1
    step: '1e-3'
    stop: 1+0.1
    value: '1'
  states: {}
- name: rrc_taps_mod
  id: variable
  parameters:
    value: np.array(firdes.root_raised_cosine(1, 1, 1.0/float(sps), eb, 200))
  states: {}
- name: rrc_taps_nfilts
  id: variable
  parameters:
    value: np.array(firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), eb, 200*nfilts))
  states: {}
- name: QPSK_Mod
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK_const
    differential: 'False'
    excess_bw: eb
    samples_per_symbol: sps
  states: {state: disabled}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: awgn_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_offset
    offset: '0'
    phase: '0'
    samp_rate: '1'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: bit_to_byte
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: multiply
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_patterned_interleaver_0
  id: blocks_patterned_interleaver
  parameters:
    pattern: '[0]+[1]*(sps-1)'
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 1e6
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: constellation[get_seq(8,2)]
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: freq_loop_bw
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    degree: '31'
    mask: '0'
    repeat: 'True'
    seed: '1'
    type: byte
  states: {state: disabled}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: 1/2**(1/2)
    loop_bw: '.01'
    max_dev: '1.5'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps_nfilts
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: gr_phil_symbol_bert_0
  id: gr_phil_symbol_bert
  parameters:
    constellation: constellation
    nbits_prbs: '8'
    print_samp_interval: int(1e4)*0
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from pyphil.symbol_sync import get_seq
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: rrc_taps_mod*(2**0.5)
    type: ccc
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: resamp_rate
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    note: A larger bandwidth can pull in a larger frequency difference at the cost of added phase noise
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 5,0,20,1
    label1: Before Carrier Sync
    size: '1024'
    type: complex
    update_time: '0.2'
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 5,0,20,1
    label1: Before Carrier Sync
    size: '1024'
    type: complex
    update_time: '0.2'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '100'
    fc: '0'
    fftsize: '1024'
    gui_hint: 5,0,20,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: sps
  id: parameter
  parameters:
    label: sps
    short_id: s
    type: intx
    value: '2'
  states: {}

connections:
- [QPSK_Mod, '0', blocks_multiply_xx_0, '1']
- [analog_const_source_x_0, '0', blocks_patterned_interleaver_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [bit_to_byte, '0', QPSK_Mod, '0']
- [blocks_add_xx_0, '0', mmse_resampler_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_patterned_interleaver_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_throttle_0, '0', gr_phil_symbol_bert_0, '0']
- [blocks_throttle_0, '0', qtgui_const_sink_x_0_1, '0']
- [blocks_vector_source_x_0, '0', blocks_patterned_interleaver_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_throttle_0, '0']
- [digital_glfsr_source_x_0, '0', bit_to_byte, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_xx_0, '1']
- [mmse_resampler_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [mmse_resampler_xx_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
