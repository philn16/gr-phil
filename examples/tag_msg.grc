options:
  parameters:
    generate_options: qt_gui
    id: tag_msg
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: gr_phil_msg_tagger_0
  id: gr_phil_msg_tagger
  parameters:
    dtype: float
    period: '100'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: tag_key_single
    type: float
    value: '0.02'
  states: {state: disabled}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    key: freq
    label: tag_key_pair
    type: float
    value: '0.02'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', gr_phil_msg_tagger_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [gr_phil_msg_tagger_0, '0', blocks_throttle_0, '0']
- [qtgui_edit_box_msg_0, msg, gr_phil_msg_tagger_0, tag_key]
- [qtgui_edit_box_msg_0_0, msg, gr_phil_msg_tagger_0, tag_key]

metadata:
  file_format: 1
